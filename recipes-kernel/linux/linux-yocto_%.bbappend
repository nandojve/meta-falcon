COMPATIBLE_MACHINE_append = "|comex"
