CFLAGS_append = " -Wno-error=maybe-uninitialized"
