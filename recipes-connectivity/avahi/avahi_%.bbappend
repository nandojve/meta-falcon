RRECOMMENDS_avahi-daemon += "avahi-factory-default"
