RRECOMMENDS_${PN}_class-target += "glibc-locale-factory-default"
