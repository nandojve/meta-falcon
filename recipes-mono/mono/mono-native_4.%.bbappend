# avoids build breaks when using no-static-libs.inc
DISABLE_STATIC = ""
