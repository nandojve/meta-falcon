EXTRA_OECONF += " \
    --enable-fpm \
    "
