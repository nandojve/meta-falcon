EXTRA_OECONF_append = '\
    --enable-mini-agent \
    --with-mib-modules="ucd_snmp agentx" \
    --with-default-snmp-version="2" \
    --with-sys-contact="suporte@peregrine.com.br" \
    --with-sys-location="Brazil" \
    --with-enterprise-oid="26138" \
'
