export TARGET_CFLAGS += "-fomit-frame-pointer"
export TARGET_CXXFLAGS = "-fomit-frame-pointer"
