RRECOMMENDS_${PN} += "bzip2 pbzip2 gzip xz p7zip"

BBCLASSEXTEND += "nativesdk"
